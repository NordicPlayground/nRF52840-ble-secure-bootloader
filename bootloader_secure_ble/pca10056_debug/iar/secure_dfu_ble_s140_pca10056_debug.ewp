# IAR project secure_dfu_ble_s140_pca10056_debug.ewp, settings and files
configuration nrf52840_xxaa_s140 (ARM)
  General.OGChipSelectEditMenu: nrf52840_xxaa nRF52840_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BLE_STACK_SUPPORT_REQD; BOARD_PCA10056; CONFIG_GPIO_AS_PINRESET; FLOAT_ABI_HARD; NRF52840_XXAA; NRF_DFU_DEBUG_VERSION; NRF_DFU_SETTINGS_VERSION=1; NRF_DFU_SVCI_ENABLED; NRF_SD_BLE_API_VERSION=6; S140; SOFTDEVICE_PRESENT; SVC_INTERFACE_CALL_AS_NORMAL_FUNCTION; SWI_DISABLE0; __HEAP_SIZE=0
  ICCARM.CCIncludePath2: ..\..\config; ..\..\..\..\..\components\ble\common; ..\..\..\..\..\components\boards; ..\..\..\..\..\components\device; ..\..\..\..\..\components\drivers_nrf\clock; ..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\components\drivers_nrf\rng; ..\..\..\..\..\components\libraries\atomic; ..\..\..\..\..\components\libraries\atomic_fifo; ..\..\..\..\..\components\libraries\balloc; ..\..\..\..\..\components\libraries\bootloader; ..\..\..\SDK.mod\components\libraries\bootloader\ble_dfu; ..\..\..\..\..\components\libraries\bootloader\dfu; ..\..\..\..\..\components\libraries\crc32; ..\..\..\..\..\components\libraries\crypto; ..\..\..\..\..\components\libraries\crypto\backend\micro_ecc; ..\..\..\..\..\components\libraries\crypto\backend\nrf_crypto_sw; ..\..\..\..\..\components\libraries\experimental_log; ..\..\..\..\..\components\libraries\experimental_log\src; ..\..\..\..\..\components\libraries\experimental_memobj; ..\..\..\..\..\components\libraries\experimental_section_vars; ..\..\..\..\..\components\libraries\fstorage; ..\..\..\..\..\components\libraries\hci; ..\..\..\..\..\components\libraries\mem_manager; ..\..\..\..\..\components\libraries\queue; ..\..\..\..\..\components\libraries\scheduler; ..\..\..\..\..\components\libraries\sha256; ..\..\..\..\..\components\libraries\strerror; ..\..\..\..\..\components\libraries\svc; ..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\components\libraries\util; ..\..\..\..\..\components\softdevice\common; ..\..\..\s140_nrf52840_6.0.0-6.alpha_API\include; ..\..\..\s140_nrf52840_6.0.0-6.alpha_API\include\nrf52; ..\..\..\..\..\components\toolchain; ..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..\..\..\components\toolchain\cmsis\include; ..\..; ..\..\..\dfu_req_handling; ..\..\..\..\..\external\fprintf; ..\..\..\..\..\external\micro-ecc\micro-ecc; ..\..\..\..\..\external\nano-pb; ..\..\..\..\..\external\segger_rtt; ..\config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: secure_dfu_ble_s140_pca10056_debug.hex
  ILINK.IlinkOutputFile: secure_dfu_ble_s140_pca10056_debug.out
  ILINK.IlinkIcfFile: secure_dfu_ble_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nRF_Log
    ../../../../../components/libraries/experimental_log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Libraries
    ../../../../../components/libraries/util/: app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../components/libraries/timer/: app_timer.c
    ../../../../../components/libraries/crc32/: crc32.c
    ../../../../../components/libraries/hci/: hci_mem_pool.c
    ../../../../../components/libraries/mem_manager/: mem_manager.c
    ../../../../../components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../../../../components/libraries/balloc/: nrf_balloc.c
    ../../../../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../../components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_nvmc.c nrf_fstorage_sd.c
    ../../../../../components/libraries/experimental_memobj/: nrf_memobj.c
    ../../../../../components/libraries/queue/: nrf_queue.c
    ../../../../../components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../../../../components/libraries/strerror/: nrf_strerror.c
    ../../../../../components/libraries/sha256/: sha256.c
  group None
    ../../../dfu_req_handling/: dfu-cc.pb.c dfu_public_key.c dfu_req_handling.c
  group nRF_Bootloader
    ../../../../../components/libraries/bootloader/: nrf_bootloader.c nrf_bootloader_app_start.c nrf_bootloader_app_start_asm.c nrf_bootloader_info.c
    ../../../../../components/libraries/bootloader/dfu/: nrf_dfu.c nrf_dfu_flash.c nrf_dfu_handling_error.c nrf_dfu_mbr.c nrf_dfu_settings.c nrf_dfu_settings_svci.c nrf_dfu_transport.c nrf_dfu_utils.c
  group Board Definition
    ../../../../../components/boards/: boards.c
  group nRF_Drivers
    ../../../../../components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../components/drivers_nrf/rng/: nrf_drv_rng.c
    ../../../../../components/drivers_nrf/hal/: nrf_nvmc.c
  group Device
    ../../../../../components/toolchain/iar/: iar_startup_nrf52840.s
    ../../../../../components/toolchain/: system_nrf52840.c
  group nRF_Crypto
    ../../../../../components/libraries/crypto/: nrf_crypto_ecdh.c nrf_crypto_ecdsa.c nrf_crypto_hash.c nrf_crypto_init.c nrf_crypto_keys.c nrf_crypto_mem.c nrf_crypto_rng.c
  group Application
    ../../: main.c
    ../config/: sdk_config.h
  group nRF_SVC
    ../../../../../components/libraries/bootloader/dfu/: nrf_dfu_svci.c nrf_dfu_svci_handler.c
    ../../../../../components/libraries/svc/: nrf_svc_handler.c
  group nRF_Segger_RTT
    ../../../../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_IAR.c SEGGER_RTT_printf.c
  group nRF_BLE_DFU
    ../../../SDK.mod/components/libraries/bootloader/ble_dfu/: nrf_ble_dfu.c
  group nano-pb
    ../../../../../external/nano-pb/: pb_common.c pb_decode.c
  group nRF_BLE
    ../../../../../components/ble/common/: ble_srv_common.c
  group nRF_micro-ecc
    ../../../../../external/micro-ecc/nrf52hf_iar/armgcc/: micro_ecc_lib_nrf52.a
  group nRF_SoftDevice
    ../../../SDK.mod/components/softdevice/common/: nrf_sdh.c
    ../../../../../components/softdevice/common/: nrf_sdh_ble.c nrf_sdh_soc.c
  group nRF_Crypto backends
    ../../../../../components/libraries/crypto/backend/micro_ecc/: micro_ecc_lib_ecdh.c micro_ecc_lib_ecdsa.c micro_ecc_lib_init.c micro_ecc_lib_keys.c micro_ecc_lib_shared.c
    ../../../../../components/libraries/crypto/backend/nrf_crypto_sw/: nrf_crypto_sw_hash.c nrf_crypto_sw_rng.c
